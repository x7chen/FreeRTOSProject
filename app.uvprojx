# Keil uVision project app.uvprojx, settings and files
target Firmware (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: app +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AFIO_MAPR_SWJ_CFG_VAL=AFIO_SWJ_JTAG_NO_SW
  c include: .\RTE\Device\STM32F103RC;.\src\MCBSTM32E\Common;.\src\main
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application
    ./src/main/: main.c app.c
  group nv_data
    ./src/nv_data/: nv_data.c
  group Drivers/log
    ./src/Drivers/log_driver/: log_thread.c
  group Drivers/nb
    ./src/Drivers/nb_driver/: nb_thread.c nb_coap.c
  group Drivers/uhf
    ./src/Drivers/uhf_driver/: uhf_packet.c uhf_protocol.c uhf_thread.c
  group Drivers/gps
    ./src/Drivers/gps_driver/: gps_parser.c gps_thread.c
  group Drivers/bt
    ./src/Drivers/bt_driver/: bt_thread.c
  group Board
    ./src/MCBSTM32E/Common/: ADC_MCBSTM32E.c LED_MCBSTM32E.c Buttons_MCBSTM32C.c
  group utils
    ./src/utils/: bytewise.c checksum.c asciicvt.c crc16_8005t.c delay.c buffer.c cmath.c
    ./src/utils/clock/: alarm.c clock.c
software components: RTOS:Config 10.0.1, RTOS:Core 10.0.1, RTOS:Event Groups 10.0.1, RTOS:Heap 10.0.1, RTOS:Message Buffer 10.0.1, RTOS:Stream Buffer 10.0.1, RTOS:Timers 10.0.1, CMSIS:CORE 5.1.1, CMSIS Driver:USART 2.2, Device:DMA 1.2, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:IWDG 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StartupConfig 8.16.0
